# Keil uVision project F407_SPI_Capture.uvprojx, settings and files
target SPI_Capture (6240000::V6.24::ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: F407_SPI_Capture +hex
  c flags: Optim=4 v6Lang=2 v6LangP=3
  c define: STM32F40_41xxx
  c include: ..\CORE;..\USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Passive capture
    ../USER/: main.c system_stm32f4xx.c
    ../CORE/: startup_stm32f40_41xxx.s
