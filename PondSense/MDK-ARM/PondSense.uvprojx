# Keil uVision project PondSense.uvprojx, settings and files
target PondSense (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: PondSense +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../BSP/DS18B20;../BSP/PHSensor;../BSP/FeedMotor;../BSP/Button;../BSP/LCD;../BSP/ESP01S;../BSP/K230;../Middleware/MQTT;../Middleware/K230;../Services;../Application/PondSense;../Config;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fsmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group BSP/Sensors
    ../BSP/DS18B20/: ds18b20.c
    ../BSP/PHSensor/: ph_sensor.c
  group BSP/Controls
    ../BSP/FeedMotor/: feed_motor.c
    ../BSP/Button/: button.c
  group BSP/LCD
    ../BSP/LCD/: lcd.c lcd_controller.c
  group BSP/K230
    ../BSP/K230/: k230_uart.c
  group BSP/ESP01S
    ../BSP/ESP01S/: esp01s.c esp01s_at.c esp01s_tcp.c
  group Middleware/MQTT
    ../Middleware/MQTT/: mqtt_client.c mqtt_codec.c
  group Middleware/K230
    ../Middleware/K230/: k230.c
  group Services
    ../Services/: sensing.c telemetry.c vision.c display.c
  group Application/PondSense
    ../Application/PondSense/: pondsense.c feeding.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
